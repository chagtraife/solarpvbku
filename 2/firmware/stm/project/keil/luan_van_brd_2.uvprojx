# Keil uVision project luan_van_brd_2.uvprojx, settings and files
target luan_van_brd_2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: luan_van_brd_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\project;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\lib\src_u8glib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_i2c.c
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c i2c.c u8g_arm.c measure.c display.c
  group u8g
    ../../lib/src_u8glib/: u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_com_std_sw_spi.c u8g_cursor.c u8g_delay.c u8g_dev_a2_micro_printer.c u8g_dev_flipdisc_2x7.c u8g_dev_gprof.c u8g_dev_ht1632.c u8g_dev_null.c u8g_dev_ssd1306_64x48.c u8g_dev_ssd1306_128x32.c u8g_dev_ssd1306_128x64.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_virtual_screen.c
